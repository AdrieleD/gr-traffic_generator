<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>traffic_generator_Distribution</key>
<param><key>id</key><value>traffic_generator_Distribution_0</value></param>
<param><key>Max</key><value>5000</value></param>
<param><key>Min</key><value>200</value></param>
<param><key>Model</key><value>4</value></param>
<param><key>Type</key><value>float</value></param>
<param><key>Shape</key><value>0</value></param>
</block>
<block>
<key>traffic_generator_Distribution</key>
<param><key>id</key><value>traffic_generator_Distribution_0_0</value></param>
<param><key>Max</key><value>10</value></param>
<param><key>Min</key><value>3</value></param>
<param><key>Model</key><value>4</value></param>
<param><key>Type</key><value>float</value></param>
<param><key>Shape</key><value>0</value></param>
</block>
<block>
<key>traffic_generator_Distribution</key>
<param><key>id</key><value>traffic_generator_Distribution_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Max</key><value>10</value></param>
<param><key>Min</key><value>3</value></param>
<param><key>Model</key><value>4</value></param>
<param><key>Type</key><value>int</value></param>
<param><key>Shape</key><value>0</value></param>
</block>
<block>
<key>traffic_generator_Distribution</key>
<param><key>id</key><value>traffic_generator_Distribution_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Max</key><value>10</value></param>
<param><key>Min</key><value>3</value></param>
<param><key>Model</key><value>4</value></param>
<param><key>Type</key><value>complex</value></param>
<param><key>Shape</key><value>0</value></param>
</block>
<block>
<key>traffic_generator_Distribution</key>
<param><key>id</key><value>traffic_generator_Distribution_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Max</key><value>5000</value></param>
<param><key>Min</key><value>200</value></param>
<param><key>Model</key><value>4</value></param>
<param><key>Type</key><value>int</value></param>
<param><key>Shape</key><value>0</value></param>
</block>
<block>
<key>traffic_generator_Distribution</key>
<param><key>id</key><value>traffic_generator_Distribution_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Max</key><value>5000</value></param>
<param><key>Min</key><value>200</value></param>
<param><key>Model</key><value>4</value></param>
<param><key>Type</key><value>complex</value></param>
<param><key>Shape</key><value>0</value></param>
</block>
<block>
<key>traffic_generator_Traffic_Generator</key>
<param><key>id</key><value>traffic_generator_Traffic_Generator_0</value></param>
<param><key>Interval</key><value>0</value></param>
<param><key>Length</key><value>0</value></param>
<param><key>Num</key><value>3</value></param>
</block>
<block>
<key>traffic_generator_Traffic_Generator</key>
<param><key>id</key><value>traffic_generator_Traffic_Generator_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Interval</key><value>0</value></param>
<param><key>Length</key><value>0</value></param>
<param><key>Num</key><value>3</value></param>
</block>
<block>
<key>traffic_generator_Traffic_Generator_Random</key>
<param><key>id</key><value>traffic_generator_Traffic_Generator_Random_0</value></param>
<param><key>Type</key><value>float</value></param>
<param><key>Interval</key><value>0</value></param>
<param><key>Length</key><value>0</value></param>
<param><key>Num</key><value>3</value></param>
</block>
<block>
<key>traffic_generator_Traffic_Generator_Random</key>
<param><key>id</key><value>traffic_generator_Traffic_Generator_Random_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Type</key><value>int</value></param>
<param><key>Interval</key><value>0</value></param>
<param><key>Length</key><value>0</value></param>
<param><key>Num</key><value>3</value></param>
</block>
<block>
<key>traffic_generator_Traffic_Generator_Random</key>
<param><key>id</key><value>traffic_generator_Traffic_Generator_Random_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Type</key><value>complex</value></param>
<param><key>Interval</key><value>1000</value></param>
<param><key>Length</key><value>5</value></param>
<param><key>Num</key><value>3</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_Random_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_Random_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_Random_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_0</sink_block_id><source_key>out_msg</source_key><sink_key>Interval</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_Random_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_0</sink_block_id><source_key>out_msg</source_key><sink_key>Length</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0_0_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_Random_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0_0_1</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0_0_1</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_0_0</sink_block_id><source_key>out_msg</source_key><sink_key>Length</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0_1</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_Random_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0_2</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0_2</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_0_0</sink_block_id><source_key>out_msg</source_key><sink_key>Interval</sink_key></connection>
<connection><source_block_id>traffic_generator_Traffic_Generator_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>msg_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>traffic_generator_Traffic_Generator_0_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0</sink_block_id><source_key>msg_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>traffic_generator_Traffic_Generator_Random_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>traffic_generator_Traffic_Generator_Random_0_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>msg_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>traffic_generator_Traffic_Generator_Random_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0_1_0</sink_block_id><source_key>msg_out</source_key><sink_key>print</sink_key></connection>
</flow_graph>
