<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_onlyTX</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq</value></param>
<param><key>block_id</key><value>my_block_0</value></param>
<param><key>function_name</key><value>get_number</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>2480000000</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>choices</key><value>[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]</value></param>
<param><key>value</key><value>2480000000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Frequence (2400-2483.5) GHz</value></param>
<param><key>labels</key><value>[i for i in range(11, 27)]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>30</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>FREQ</value></param>
</block>
<block>
<key>Kteste_contador_py_ii</key>
<param><key>id</key><value>Kteste_contador_py_ii_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/home/lesc/Área de Trabalho/TX.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>pad_front</key><value>2000</value></param>
<param><key>pad_tail</key><value>2000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>ieee802_15_4_mac</key>
<param><key>id</key><value>ieee802_15_4_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_phy</key>
<param><key>id</key><value>ieee802_15_4_phy_0</value></param>
</block>
<block>
<key>ieee802_15_4_rime_stack</key>
<param><key>id</key><value>ieee802_15_4_rime_stack_0</value></param>
<param><key>bc_channels</key><value>[129]</value></param>
<param><key>rime_add</key><value>[23,42]</value></param>
<param><key>ruc_channels</key><value>[132]</value></param>
<param><key>uc_channels</key><value>[131]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>This is for loopback testing. Disable this block an enable the USRP blocks for over-the-air transmission.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>you can connect to the Socket PDU with: 'nc -u localhost 52002'</value></param>
</block>
<block>
<key>traffic_generator_Distribution</key>
<param><key>id</key><value>traffic_generator_Distribution_0</value></param>
<param><key>Max</key><value>4000</value></param>
<param><key>Min</key><value>500</value></param>
<param><key>Model</key><value>4</value></param>
<param><key>Type</key><value>int</value></param>
<param><key>Shape</key><value>0</value></param>
</block>
<block>
<key>traffic_generator_Distribution</key>
<param><key>id</key><value>traffic_generator_Distribution_1</value></param>
<param><key>Max</key><value>15</value></param>
<param><key>Min</key><value>5</value></param>
<param><key>Model</key><value>4</value></param>
<param><key>Type</key><value>int</value></param>
<param><key>Shape</key><value>0</value></param>
</block>
<block>
<key>traffic_generator_Traffic_Generator</key>
<param><key>id</key><value>traffic_generator_Traffic_Generator_0</value></param>
<param><key>Interval</key><value>0</value></param>
<param><key>Length</key><value>0</value></param>
<param><key>Num</key><value>5</value></param>
</block>
<block>
<key>traffic_generator_Traffic_Generator_Random</key>
<param><key>id</key><value>traffic_generator_Traffic_Generator_Random_0</value></param>
<param><key>Type</key><value>int</value></param>
<param><key>Interval</key><value>0</value></param>
<param><key>Length</key><value>0</value></param>
<param><key>Num</key><value>5</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>Kteste_contador_py_ii_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>ieee802_15_4_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>pdus</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>foo_packet_pad_0</source_block_id><sink_block_id>ieee802_15_4_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>Kteste_contador_py_ii_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>app out</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>pdu out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_phy_0</sink_block_id><source_key>pdu out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_phy_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_phy_0</source_block_id><sink_block_id>foo_packet_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>bcout</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>toMAC</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_Random_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_0</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_0</sink_block_id><source_key>out_msg</source_key><sink_key>Interval</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_1</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_Random_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>traffic_generator_Distribution_1</source_block_id><sink_block_id>traffic_generator_Traffic_Generator_0</sink_block_id><source_key>out_msg</source_key><sink_key>Length</sink_key></connection>
<connection><source_block_id>traffic_generator_Traffic_Generator_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>msg_out</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>traffic_generator_Traffic_Generator_Random_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>msg_out</source_key><sink_key>bcin</sink_key></connection>
</flow_graph>
